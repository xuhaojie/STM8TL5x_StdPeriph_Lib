# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F2 STM8L101F2
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..; ..\..\..\..\..\libraries\STM8T85x_StdPeriph_Driver\inc; ..\..\..\..\..\utilities
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.s19
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group STM8T85x_StdPeriph_Driver
    ../../../../../libraries/STM8T85x_StdPeriph_Driver/src/: stm8t85x_awu.c stm8t85x_beep.c stm8t85x_clk.c stm8t85x_exti.c stm8t85x_flash.c stm8t85x_gpio.c stm8t85x_i2c.c stm8t85x_itc.c stm8t85x_iwdg.c stm8t85x_rst.c stm8t85x_spi.c stm8t85x_tim2.c stm8t85x_tim3.c stm8t85x_tim4.c stm8t85x_usart.c stm8t85x_wfe.c stm8t85x_wwdg.c
  group User
    ../: main.c stm8t85x_it.c
  group Utilities
    ../../../../../utilities/: mono_lcd.c
