# IAR project my_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8TL53C4 STM8TL53C4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..; ..\..\..\libraries\stm8tl5x_StdPeriph_Driver\inc; ..\..\..\utilities
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: my_project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group stm8tl5x_StdPeriph_Driver
    ../../../libraries/stm8tl5x_StdPeriph_Driver/src/: stm8tl5x_awu.c stm8tl5x_beep.c stm8tl5x_clk.c stm8tl5x_exti.c stm8tl5x_flash.c stm8tl5x_gpio.c stm8tl5x_i2c.c stm8tl5x_itc.c stm8tl5x_iwdg.c stm8tl5x_rst.c stm8tl5x_spi.c stm8tl5x_tim2.c stm8tl5x_tim3.c stm8tl5x_tim4.c stm8tl5x_usart.c stm8tl5x_wfe.c stm8tl5x_wwdg.c
  group User
    ../: main.c stm8tl5x_it.c
  group Utilities
    ../../../Utilities/: mono_lcd.c
